# Keil uVision project GPRS测试程序.uvproj, settings and files
target GPRS测试程序（动态IP） (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: GPRS测试程序（动态IP） +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c delay.c uart.c mqtt.c
