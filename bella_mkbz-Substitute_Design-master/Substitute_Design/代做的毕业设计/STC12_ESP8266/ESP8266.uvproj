# Keil uVision project ESP8266.uvproj, settings and files
target STC12_ESP8266 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: ESP8266 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Lib
  group User
    ./User/: main.c
    ./Lib/: bsp_esp8266.c delay.c uart.c
