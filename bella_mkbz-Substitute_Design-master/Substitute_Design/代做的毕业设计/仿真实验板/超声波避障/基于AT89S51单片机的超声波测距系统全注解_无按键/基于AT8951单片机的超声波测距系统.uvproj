# Keil uVision project 基于AT8951单片机的超声波测距系统.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: 基于AT8951单片机的超声波测距系统 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: AT89S52_CSB.C lcd.c Sound_Wave.c
