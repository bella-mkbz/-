# Keil uVision project Pro.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Pro +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c lcd.c adc0832.c delay.c button.c
